# Keil uVision project pong52.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pong52 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .
  group Header
    ./: extra_function.h
  group C Source
    ./: extra_function.c main.c
